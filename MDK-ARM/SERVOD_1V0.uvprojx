# Keil uVision project SERVOD_1V0.uvprojx, settings and files
target SERVOD_1V0 (6210000::V6.21::ARMCLANG)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: SERVOD_1V0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../all_pid/src;../workchain
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: mcpwm.c current_loop.c velocity_loop.c position_loop.c parameter.c motion_control.c ntc_calculate.c modbus.c oled.c sys.c tamagawa.c utils.c filter.c crc_16.c sin_table.c works.c main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c amotor_port.c
    ../all_pid/src/: apid_exfunc.c apid.c apid_auto_tune_ZNmode.c apid_ex_fuzzy.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group WorkChain
    ../workchain/: workchain.c
software components: CMSIS:CORE 6.0.0, Utilities:perf_counter:Core 2.3.1
